options:
  parameters:
    author: Avi
    category: TAUSAT Components
    generate_options: hb
    id: Avi1
    output_language: python
    run: 'False'
    title: Frequency Modulator
  states: {}

blocks:
- name: dev_freq
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: dev_freq
    quad_rate: 8*samp_rate
    tau: '75e-6'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [pad_source_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
