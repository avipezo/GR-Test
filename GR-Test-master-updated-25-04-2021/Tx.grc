options:
  parameters:
    author: tausat
    generate_options: qt_gui
    id: tausat
    output_language: python
    title: Transmitter
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 145.97e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 0 ,0,1,1,1,0,0,0,1,0)
  states: {}
- name: fsk_modulator_0
  id: fsk_modulator
  parameters:
    in_rate: '48000'
    out_rate: 2.4e6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: raised_cosine_0
  id: raised_cosine
  parameters:
    baud_rate: '9600'
    gain: '4'
    roll_off: '0.35'
    samp_rate: '48000'
    taps: '32'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_vector_source_x_0, '0', raised_cosine_0, '0']
- [fsk_modulator_0, '0', qtgui_sink_x_0, '0']
- [fsk_modulator_0, '0', uhd_usrp_sink_0, '0']
- [raised_cosine_0, '0', fsk_modulator_0, '0']

metadata:
  file_format: 1
