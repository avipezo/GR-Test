options:
  parameters:
    author: Avi
    category: TAUSAT Components
    generate_options: hb
    id: Avi
    output_language: python
    title: Raised Cosine Filter
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '4'
  states: {}
- name: roll_off
  id: variable
  parameters:
    value: '0.65'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: Avi_0
  id: Avi
  parameters: {}
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: baud_rate
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: parameter_0
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: roll_off
    gain: gain
    interp: '5'
    ntaps: taps
    samp_rate: samp_rate
    sym_rate: baud_rate
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: roll_off
    gain: gain
    interp: '5'
    ntaps: taps
    samp_rate: samp_rate
    sym_rate: baud_rate
    type: interp_fir_filter_fff
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', root_raised_cosine_filter_0, '0']
- [pad_source_0, '0', blocks_char_to_float_0, '0']
- [root_raised_cosine_filter_0, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
